Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-20T11:15:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 20 11:15:30 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{90B437C0-8F6D-4EBB-9D33-3F4CEC12A613}\ifc * Database version: 5507 * Database creation date: Wed Mar 20 11:15:29 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 20 11:15:29 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 20 11:15:29 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3910 Washbasin faucet, 3910(2016):3910 Washbasin faucet:319400
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 137 mm; NominalHeight: 137 mm; NominalWidth: 48.5 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3910(2016); ConvergoRefNr: 0087-1803-0031-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Washbasin faucet with fixed spout and aerator; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 15/03/2019
Type - Green Building Properties(Type) - Approval KIWA SE Type Approval: 1413; Customs Code: 84818011; EAN Number: 6414150077791; EN Standard: EN 817; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/3910; VVS Number: 701240004
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3910; Catalog Drawing URL: http://static.oras.com/catdrw/3910; Class: Single lever; Description: Washbasin faucet with fixed spout and aerator; Dimension Drawing URL: http://static.oras.com/dimdrw/3910; FDV Document URL: http://www.oras.com/datasheet/3910/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3910; Long Marketing: Washbasin faucet with fixed spout and aerator. There are also in-built limitation options for water temperature and maximum flow-rate. Flow controller 6.0 l/min.; Manufacturer: Oras; Market: INT;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 3910 Washbasin faucet; Name_en: 3910 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 540 x 146 x 59; Package Weight: 1.208 kg; Product Code: 3910; Product Datasheet: http://www.oras.com/datasheet/3910/en; Product Family: Oras Saga; Product Image URL: http://static.oras.com/image/3910; Product URL: http://static.oras.com/3910; Type Name: 3910 Washbasin faucet; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: Ø10 mm; Flow: Limitation option for maximum flow rate; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/3910; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Noise Class: I (ISO 3822) Oras lab.; Pipes: Copper inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Spare Parts: http://static.oras.com/sp/3910; Spout Type: Fixed spout; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3910(2016); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3910; Name: 3910 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 48.5x137x136 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3910; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3910 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0331575 m2; Volume: 0.000915009 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3910(2016): 3910 Washbasin faucet; Family and Type: 3910(2016): 3910 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3910(2016): 3910 Washbasin faucet; Type Id: 3910(2016): 3910 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
